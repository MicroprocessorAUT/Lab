# Keil uVision project KEIL_ATSAM_Assm.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAM3N4A Microchip
  pack: Atmel.SAM3N_DFP.1.0.62
  cpu: IRAM(0x20000000,0x00006000) IROM(0x00400000,0x00040000) IROM2(0x00800000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KEIL_ATSAM_Assm +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT5: ROM 0x800000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Source Group 1
    ./: main.s
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
